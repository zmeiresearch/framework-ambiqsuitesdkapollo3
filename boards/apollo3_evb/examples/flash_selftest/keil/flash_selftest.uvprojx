# Keil uVision project flash_selftest.uvprojx, settings and files
target flash_selftest (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: flash_selftest
  AfterMake: fromelf --bin --output bin\flash_selftest.bin bin\flash_selftest.axf
  AfterMake: fromelf -cedrst --output bin\flash_selftest.txt bin\flash_selftest.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PART_APOLLO3 AM_PACKAGE_BGA keil
  c include: ../src;../../../../../CMSIS/ARM/Include;../../../bsp;../../../../../utils;../../../../../CMSIS/AmbiqMicro/Include;../../../../..;../../../../../devices;../../../../../mcu/apollo3
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\flash_selftest.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: flash_selftest.c
  group utils
    ../../../../../utils/: am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
